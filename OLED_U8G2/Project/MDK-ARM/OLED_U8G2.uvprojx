# Keil uVision project OLED_U8G2.uvprojx, settings and files
target OLED_U8G2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED_U8G2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER
  c include: ..\..\Core\Inc;..\..\Middlewares\U8G2;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Startup/: startup_stm32f103xb.s
  group Core
    ../../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c system_stm32f1xx.c soft_iic.c u8g2_port.c u8g2_app.c cn_font.c
  group STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c
  group U8G2
    ../../Middlewares/U8G2/: u8g2_setup.c u8g2_buffer.c u8g2_cleardisplay.c u8g2_d_setup.c u8g2_d_memory.c u8g2_font.c u8g2_fonts_min.c u8g2_hvline.c u8g2_ll_hvline.c u8g2_line.c u8g2_box.c u8g2_circle.c u8g2_arc.c u8g2_polygon.c u8g2_bitmap.c u8g2_kerning.c u8g2_intersection.c u8x8_d_ssd1306_128x64_noname.c u8x8_display.c u8x8_setup.c u8x8_cad.c u8x8_byte.c u8x8_gpio.c u8x8_string.c u8x8_8x8.c
  group Readme
    ../../: readme.txt
